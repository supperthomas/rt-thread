# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, CORE_SEL_MCUTOP
  c include: ..\..\..\libcpu\arm\common;..\libraries\SDK\platform\va9638p\plat\plat_demo\plat_dev;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\libraries\SDK\platform\va9638p\plat\plat_demo\plat_drv;..\libraries\SDK\vcomlib\vstdlib;..\libraries\SDK\platform\va9638p\chip\driver\reg;..\..\..\components\finsh;..\libraries\SDK\platform\va9638p\chip\core;..\..\..\include;..\libraries\SDK\platform\va9638p\test;..\libraries\SDK\cfg\cfg_test;.;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\drivers\phy;applications;board;..\libraries\SDK\platform\va9638p\chip\driver\include;..\libraries\SDK;..\..\..\libcpu\arm\cortex-m3;..\libraries\SDK\vcomlib\vstdio;..\libraries\SDK\platform\va9638p\chip\device;..\libraries\HAL_Drivers;..\libraries\SDK\platform\va9638p\plat\plat_demo\map_boot
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_console.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh.c msh_parse.c cmd.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kstdio.c kstring.c kerrno.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/SDK/vcomlib/vstdio/: vdebug.c vdebug_assert.c vstdio.c vdebug_uart.c
    ../libraries/SDK/vcomlib/vstdlib/: vstdlib.c vstdlib_vsprintf.c
    ../libraries/SDK/platform/va9638p/chip/driver/source/: vdrv_timer.c vdrv_dma.c vdrv_mem.c vdrv_spi.c vdrv_mbox.c vdrv_uart.c vdrv_wd.c vdrv_gpio.c vdrv_ckm.c
    ../libraries/SDK/platform/va9638p/plat/plat_demo/plat_drv/: vpla_ckm.c vpla_timer.c vpla_uart.c vpla_gpio.c
    ../libraries/SDK/platform/va9638p/chip/core/: vnvic_fpb.c vnvic_interrupt.c vnvic_system.c cpu_core.asm
    ../libraries/SDK/platform/va9638p/chip/device/: vdrv_spiflash.c
    ../libraries/SDK/platform/va9638p/plat/plat_demo/: vstddrv.c vstdcore.c
