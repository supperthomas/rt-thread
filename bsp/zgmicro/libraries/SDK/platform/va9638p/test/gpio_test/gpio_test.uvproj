# Keil uVision project gpio_test.uvproj, settings and files
target Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x5FFFF) CLOCK(26000000) CPUTYPE("Cortex-M3")
  output: unitTest
  AfterMake: .\tools\build_bin.bat "$KARM"\ARMCC\bin @L $L %L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CORE_SEL_MCUTOP
  c misc: --diag_suppress=177
  c include: .;..;..\..\..\..\cfg\cfg_test;..\..\plat\plat_demo;..\..\plat\plat_demo\map_boot\;..\..\plat\plat_demo\plat_dev\;..\..\plat\plat_demo\plat_drv\;..\..\..\..;..\..\..\..\vcomlib\vstdlib;..\..\..\..\vcomlib\vstdio;..\..\..\..\vcomlib\vstdio\segger;..\..\..\..\vcomlib\vstdio\segger\Config;..\..\..\..\vcomlib\vstdio\segger\SEGGER;..\..;..\..\chip\driver\include;..\..\chip\driver\reg;..\..\chip\core;..\..\plat;..\..\chip\device;..\..\..\..\systemOS;..\..\..\..\systemOS\RTT\include
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\plat\plat_demo\map_boot\linkscripts\section_placement_coderam.sct
  link misc: --diag_suppress=L6329,L6314
  group app
    ./: main.c
  group vkernel
    ../../../../: vstdlib.h vstdcore.h vstdos.h vstdio.h vstddrv.h
    ../../plat/plat_demo/plat_drv/: vpla_gpio.c vpla_timer.c vpla_uart.c vpla_ckm.c
    ../../plat/plat_demo/: vstdcore.c vstddrv.c
    ../../chip/driver/source/: vdrv_ckm.c vdrv_dma.c vdrv_gpio.c vdrv_mbox.c vdrv_mem.c vdrv_timer.c vdrv_uart.c vdrv_wd.c vdrv_spi.c
    ../../../../vcomlib/vstdio/: vstdio.c vdebug.c vdebug_assert.c vdebug_uart.c
    ../../../../vcomlib/vstdlib/: vstdlib.c vstdlib_vsprintf.c
    ../../chip/core/: vnvic_fpb.c vnvic_interrupt.c cpu_core.asm vnvic_system.c
    ../../chip/device/: vdrv_spiflash.c
  group rtthread
    ../../../../systemOS/RTT/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mem.c mempool.c object.c scheduler.c thread.c timer.c
    ../../../../systemOS/RTT/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
