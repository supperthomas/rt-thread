# Keil uVision project lib_test.uvproj, settings and files
target Lib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x5FFFF) CLOCK(26000000) CPUTYPE("Cortex-M3")
  output: vdrv_spiflash (library)
  AfterMake: .\tools\build_bin.bat "$KARM"\ARMCC\bin @L $L %L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CORE_SEL_MCUTOP,CORE_TOP_OTP_LIB
  c misc: --diag_suppress=177
  c include: .;..;..\..\..\..\cfg\cfg_test;..\..\plat\plat_demo;..\..\plat\plat_demo\map_boot\;..\..\plat\plat_demo\plat_dev\;..\..\plat\plat_demo\plat_drv\;..\..\..\..;..\..\..\..\vcomlib\vstdlib;..\..\..\..\vcomlib\vstdio;..\..\..\..\vcomlib\vstdio\segger;..\..\..\..\vcomlib\vstdio\segger\Config;..\..\..\..\vcomlib\vstdio\segger\SEGGER;..\..;..\..\chip\driver\include;..\..\chip\driver\reg;..\..\chip\core;..\..\plat;..\..\chip\device;..\..\..\..\systemOS;..\..\..\..\systemOS\uCOS;..\..\..\..\systemOS\uCOS\os_cfg;..\..\..\..\systemOS\uCOS\uC-CPU;..\..\..\..\systemOS\uCOS\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\systemOS\uCOS\uC-LIB;..\..\..\..\systemOS\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\systemOS\uCOS\uCOS-III\Source;..\..\..\..\systemOS\timer;..\..\..\..\systemOS\ipc
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\plat\plat_demo\map_boot\linkscripts\section_placement_coderam.sct
  link misc: --diag_suppress=L6329,L6314
  group lib
    ../../chip/device/: vdrv_spiflash.c
