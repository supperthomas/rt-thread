# Keil uVision project 7638Xiisdsp.uvproj, settings and files
target VA9647X_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x5FFFF) CLOCK(26000000) CPUTYPE("Cortex-M3")
  output: va9647x_debug
  AfterMake: .\tools\build_bin.bat "$KARM"\ARMCC\bin @L $L %L
  c flags: OneElfS=1 uC99=1
  c define: CORE_SEL_MCUTOP,CORE_MCU_ONLY
  c misc: --diag_suppress=177,111
  c include: ..\..\..\..\cfg\cfg_9647Xslave;..\..\plat\plat_demo;..\..\plat\plat_demo\map_boot\;..\..\plat\plat_47X\plat_dev\;..\..\plat\plat_demo\plat_dev\;..\..\plat\plat_demo\plat_drv\;..\..\..\..;..\..\..\..\vcomlib\vstdlib;..\..\..\..\vcomlib\vstdio;..\..\..\..\vcomlib\vstdio\segger;..\..\..\..\vcomlib\vstdio\segger\Config;..\..\..\..\vcomlib\vstdio\segger\SEGGER;..\..\..\..\platform;..\..\chip\driver\include;..\..\chip\driver\reg;..\..\chip\core;..\..\plat;..\..\chip\device;..\..\..\..\systemOS;..\..\..\..\systemOS\uCOS;..\..\..\..\systemOS\uCOS\os_cfg;..\..\..\..\systemOS\uCOS\uC-CPU;..\..\..\..\systemOS\uCOS\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\systemOS\uCOS\uC-LIB;..\..\..\..\systemOS\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\systemOS\uCOS\uCOS-III\Source;..\..\..\..\systemOS\timer;..\..\..\..\systemOS\ipc;..\..\..\..\systemOS\FreeRTOS\include;..\..\..\..\systemOS\FreeRTOS\portable\ZGMicro\ARM\ARM_CM3;..\..\..\..\systemOS\vcoroutine;.\app;..\..\plat\plat_47X\plat_die;.\mode;.\trans
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\plat\plat_47X\map_slavedie\linkscripts\section_placement_toprom.sct
  link misc: --diag_suppress=L6329,L6314
  group app
    ./: main.c
    ./app/: vapp_host.c vapp_pmu.c vapp_slave.c
  group mode
    ./mode/: vapp_mode_dsp.c vapp_mode_iisin.c vapp_mode_iisout.c vmode_common.c vapp_mode_adc.c vapp_mode_mix.c vapp_mode_merge.c vapp_mode_split.c vapp_mode_softin.c vapp_mode_copy.c vapp_mode_dac.c vapp_mode_delay.c
  group trans
    ./trans/: vapp_die.c
    ../../plat/plat_47X/plat_die/: vapp_die_transmit.c
  group vkernel
    ../../../../: vstdlib.h vstdcore.h vstdos.h vstdio.h vstddrv.h
    ../../plat/plat_demo/plat_drv/: vpla_gpio.c vpla_i2c.c vpla_iis.c vpla_led.c vpla_timer.c vpla_uart.c vpla_ckm.c vpla_aif.c
    ../../plat/plat_demo/plat_dev/: vpla_flash.c vpla_trace.c vpla_box.c vpla_dsp.c vpla_fmw.c
    ../../plat/plat_demo/: vstdcore.c vstddrv.c
    ../../chip/device/: vdrv_spiflash.c vdrv_9900.c lcd_oled.c vdrv_cdc.c
    ../../chip/driver/source/: vdrv_aes.c vdrv_asrc.c vdrv_ckm.c vdrv_dma.c vdrv_espi.c vdrv_gpio.c vdrv_i2c.c vdrv_iis.c vdrv_ipc.c vdrv_led.c vdrv_mbox.c vdrv_mem.c vdrv_otg.c vdrv_spi.c vdrv_timer.c vdrv_uart.c vdrv_udc.c vdrv_udc_aud.c vdrv_udc_serial.c vdrv_udc_serial_des.c vdrv_usbinfo.c vdrv_wd.c vdrv_aif.c vdrv_hd_cport.c vdrv_trng.c vdrv_lcd.c
    ../../../../systemOS/timer/: vsys_timer.c
    ../../../../systemOS/uCOS/uC-CPU/: cpu_core.c
    ../../../../systemOS/uCOS/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
    ../../../../systemOS/uCOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../systemOS/uCOS/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
    ../../../../systemOS/uCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../systemOS/: vstdos.c
    ../../../../vcomlib/vstdio/: vstdio.c vdebug.c vdebug_assert.c vdebug_flash.c vdebug_itm.c vdebug_mem.c vdebug_rtt.c vdebug_sim.c vdebug_trace.c vdebug_uart.c vdebug_usb.c vdebug_uart_rtt.c vdebug_usb_rtt.c
    ../../../../vcomlib/vstdlib/: vlist.c vprotobuf.c vstdlib.c vstdlib_vsprintf.c vsys_mem.c vsys_mem_info.c vsys_mem_tlsf.c vsys_mem_blk.c vsys_sharemem.c
    ../../chip/core/: vnvic_fpb.c vnvic_system.c vnvic_interrupt.c cpu_core.asm
    ../../../../systemOS/ipc/: vpla_ipc_control.c vdev_ipc.c vos_ipc.c vos_rpc.c
    ../../../../vcomlib/vstdio/segger/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../../../vcomlib/vstdio/segger/: SEGGER_SYSVIEW_Wrap.c
    ../../../../systemOS/FreeRTOS/portable/ZGMicro/ARM/ARM_CM3/: port.c
    ../../../../systemOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../systemOS/vcoroutine/: vcoroutine.c
    ../../plat/plat_47X/plat_dev/: vpla_cdc.c
