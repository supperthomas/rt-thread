# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: nRF5340_xxAA:Application Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x08000000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, NRF5340_XXAA_APPLICATION, RT_USING_ARM_LIBC
  c misc: -fshort-enums
  c include: applications;.;..\libraries\cmsis\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\drivers;..\..\..\components\finsh;.;..\..\..\include;packages\nrfx-latest;packages\nrfx-latest\drivers;packages\nrfx-latest\drivers\include;packages\nrfx-latest\mdk;packages\nrfx-latest\hal;packages\nrfx-latest\drivers\src;packages\nrfx-latest\usbd\class\cdc\acm;packages\nrfx-latest\usbd\class\cdc;packages\nrfx-latest\usbd;packages\nrfx-latest\libuarte;packages\nrfx-latest\atomic;packages\nrfx-latest\atomic_fifo;packages\nrfx-latest\util;packages\nrfx-latest\balloc;packages\nrfx-latest\queue;packages\nrfx-latest\timer;packages\nrfx-latest\delay;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc
  asm define: BOARD_PCA10095 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF5340_XXAA_APPLICATION __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10095,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF5340_XXAA_APPLICATION,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: application.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c
    ../libraries/drivers/: drv_adc.c drv_gpio.c drv_hwtimer.c drv_i2s.c drv_ipc.c drv_pwm.c drv_qspi_flash.c drv_rtc.c drv_uarte.c drv_usb_cdc_acm.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group nrf_Drivers
    packages/nrfx-latest/drivers/src/: nrfx_twi_twim.c nrfx_spis.c nrfx_dppi.c nrfx_ppi.c nrfx_uarte.c nrfx_comp.c nrfx_qdec.c nrfx_ipc.c nrfx_rng.c nrfx_saadc.c nrfx_egu.c nrfx_pwm.c nrfx_lpcomp.c nrfx_temp.c nrfx_qspi.c nrfx_twi.c nrfx_gpiote.c nrfx_adc.c nrfx_twis.c nrfx_power.c nrfx_systick.c nrfx_nvmc.c nrfx_pdm.c nrfx_i2s.c nrfx_twim.c nrfx_nfct.c nrfx_clock.c nrfx_rtc.c nrfx_spim.c nrfx_timer.c nrfx_wdt.c
    packages/nrfx-latest/helpers/: nrfx_flag32_allocator.c
    packages/nrfx-latest/libuarte/: nrf_libuarte_drv.c nrf_libuarte_async.c
    packages/nrfx-latest/balloc/: nrf_balloc.c
    packages/nrfx-latest/util/: nrf_assert.c app_error_handler_keil.c app_error_weak.c app_util_platform.c app_error.c
    packages/nrfx-latest/mdk/: system_nrf5340_application.c arm_startup_nrf5340_application.s
    packages/nrfx-latest/timer/: timer_drv_rtc.c
    packages/nrfx-latest/queue/: nrf_queue.c
    packages/nrfx-latest/libs/: nusbd.lib
software components: CMSIS:CORE 5.3.0, Device:Startup 8.40.3
